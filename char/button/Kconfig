## char/button/Kconfig
```kconfig
config BUTTON_MY
  tristate "Button Driver"
  default y
  help
    this is buttons driver for FriendlyARM Mini2440 development boards
```
